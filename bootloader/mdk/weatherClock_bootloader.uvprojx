# Keil uVision project weatherClock_bootloader.uvprojx, settings and files
target f407_boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: weatherClock_bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\app;..\cmsis;..\..\firmware\cmsis\core;..\..\firmware\cmsis\device;..\..\firmware\driver\inc;..\..\my_driver;..\..\my_driver\board
  asm include: ..\cmsis;..\..\firmware\cmsis\core;..\..\firmware\cmsis\device;..\..\firmware\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../app/: main.c boot_UART.c boot_crc.c boot_update.c
  group CMSIS
    ../cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c system_stm32f4xx.h
  group STM32F4xx_StdPeriph_Driver
    ../../firmware/driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_flash.c
  group W25Q128
    ../../my_driver/board/: SPI.c
    ../../my_driver/25q128/: 25q128.c
